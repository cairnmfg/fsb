## Config.in
```kconfig
source "$NERVES_DEFCONFIG_DIR/package/puredata/Config.in"
source "$NERVES_DEFCONFIG_DIR/package/supercollider/Config.in"
```
